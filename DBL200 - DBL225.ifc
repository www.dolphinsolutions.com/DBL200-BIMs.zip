Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2019-05-30T17:11:51
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 30 17:11:51 2019 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{CD7CCC05-CDAA-47DA-ADE3-8F42667DB5F3}\ifc * Database version: 5507 * Database creation date: Thu May 30 17:11:50 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 30 17:11:51 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 30 17:11:51 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: P:\Fastrack\53721_DOLPHIN SOLUTIONS LIMITED\ADDITIONAL DRAWINGS 2019 BIM\05$MAY\DBL200 - DBL225.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Building Story: yes; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 1 Default: no; Symbol at End 2 Default: yes; Line Pattern: -3000010; Line Weight: 1; Color: 0

# IfcBuildingElementProxy: DBL200 / DBL225 Dolphin Counter Mounted Electronic Infrared Tap, DBL200 - DBL225:DBL200 / DBL225 Dolphin Counter Mounted Electronic Infrared Tap:22458
In: Level 1
Material: Chrome, Glass
Constraints - Moves With Nearby Elements: no; Offset: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.000620525 m3; Counter Thickness: Min 2mm - Max 27mm; Counter hole: Ø34 - 36mm; Height: 368mm; Projection: 134mm; Width: Ø44mm
Pset_ManufacturerTypeInformation - Manufacturer: Dolphin Solutions Ltd.
Pset_BuildingElementProxyCommon - Reference: DBL200 / DBL225 Dolphin Counter Mounted Electronic Infrared Tap
Identity Data - Address: Southpoint, Compass Park, Junction Road, Bodiam, TN32 5BS; Tel No.: +44 (0) 1424 202224; Description: Counter mounted electronic infrared tap; Assembly Description: Misc. Other Plumbing Systems; URL: www.dolphinsolutions.co.uk; Assembly Code: D2090900; Manufacturer: Dolphin Solutions Ltd.; Email: info@dolphinsolutions.co.uk; Model: DBL200C/S-2 = Battery Powered / DB225C/S-2 = Transformer Powered; Fax No.: +44 (0) 1424 205200
Other - BREEAM compliant: yes; WRAS approved: yes; SKA Rating Compliant: yes
Electrical - Power options: Plug-in 9 Volt transformer or 9 Volt Battery
General - Product Data: WRAS Approved product. Touch Free Electronic Tap - Tap is activated when the user brings hands within the state of the art electronic infrared sensor. Quality polished or brushed chrome plated brass finishes available from stock – other finishes available to special order. Ultimate Hygiene-Prevents cross contamination › Flow rate – 3.8 litres/minute with our standard fitted flow regulator at any pressure between 0 and 6 bar (other flow rates such as 1.89 and 1.33 LPM available to special order – please enquire) › Flow time once user's hands are removed from the tap - 1 second (adjustable by using remote control DB51) › Filters, fixing bolts, installation instructions and power source supplied with each tap › 2 year manufacturer's warranty › Ideal for counter top basins › Mandatory Hygiene Flush is available - can be set to 12, 24 or 48 Hour intervals - optional extra & must be specified when ordering › Complies with SKA rating criteria › Interchangeable STD M22/24 Neoperl Aerator insert › We recommend our Dolphin Blue DB61 TMV3 be used in conjunction with this Dolphin Blue tap › Our low flow taps are fully BREEAM compliant and contribute to up to five BREEAM WAT 1 credits. › Listed on the Government’s Water Technology List (WTL) as part of the Enhanced Capital Allowance (ECA) scheme. The ECA allows a business to offset the cost of purchasing eligible plant and machinery against its taxable profits; Warranty: 2 year; Product Page Link: https://www.dolphinsolutions.co.uk/product/counter-mounted-electronic-infrared-tap
Plumbing - Water supply connector: 3/8" BSP; Water Supply: Single inlet - cold or pre-mixed (see DB60 mixer valve)
Materials and Finishes - Finish: DBL200C = Polished Chrome / DBL200S-2 = Brushed / Satin Chrome
